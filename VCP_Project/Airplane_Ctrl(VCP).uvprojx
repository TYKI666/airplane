# Keil uVision project Airplane_Ctrl(VCP).uvprojx, settings and files
target Player_Flight (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Player_Flight +hex
  AfterMake: fromelf --bin --output ./build/@L.bin ./build/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,VCP_PORT
  c misc: --C99
  c include: ..\Code\Ctrl;..\Code\Driver;..\Code\STM32_LIB\CMSIS;..\Code\STM32_LIB\LIB\inc;..\Code\Applications;..\Code\USB_LIB;..\Code\USB_VCP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Ctrl
    ../Code/Ctrl/: Config.h include.h Init.c main.c Scheduler.c Param.c Data_Transfer.c Data.c filter.c IMU.c mpu_prepare.c PID.c RC.c Voltage.c Ctrl.c CustomCtrl.c MotionCal.c Loc_data.c Alt_data.c AltCtrl.c Kalman.c EventLog.c vl53L1x.c
    ../Code/Applications/: Flip.c Player_Flight.lib
  group Driver
    ../Code/Driver/: bsp_SysTick.c Drv_ADC.c Drv_ak8975.c Drv_Flash.c Drv_icm20602.c Drv_mpu6050.c Drv_LED.c Drv_Nrf24l01.c Drv_SPI.c Drv_spl06.c Drv_Uart1.c Drv_Uart2.c Drv_Uart3.c Drv_ws2812.c Drv_Buzzer.c Drv_vl53L1x.c Drv_i2c.c Motor.c mymath.c stm32f10x_it.c
  group STM32_LIB
    ../Code/STM32_LIB/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h
    ../Code/STM32_LIB/LIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group USB_LIB
    ../Code/USB_LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_VCP
    ../Code/USB_VCP/: Queue.c usb_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group StartUP
    ./: startup_stm32f10x_md.s
  group UpdateLog
    ../Code/: update_log.txt
